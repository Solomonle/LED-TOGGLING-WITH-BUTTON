<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Toggle.ewp</path>
    </project>
    <project>
        <path>C:\Users\solomon\OneDrive\Desktop\TOGGLE\Toggle.ewp</path>
    </project>
    <batchBuild />
</workspace>
